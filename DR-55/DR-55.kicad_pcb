# Repository Max-Frahm/DR-55

File README.md:

# DR-55
 DR-55 Drum machine

 License - CC BY 4.0

## KiCad design DR-55/DR-55.kicad_pcb

Parts:
J1: KICK; PJ301M-12
J2: SNARE; PJ301M-12
J3: RIM; PJ301M-12
J4: HIHAT; PJ301M-12
J5: ACCENT; PJ301M-12
J6: OUT; PJ301M-12

Connections:
/Hi Hats/TRGIN: J4.1; also elsewhere on the board
/Kick/TRGIN: J1.1; also elsewhere on the board
/OUTPUT/OUT: J6.1; also elsewhere on the board
/OUTPUT/TRGIN: J5.1; also elsewhere on the board
/Rim Shot/TRGIN: J3.1; also elsewhere on the board
/Snare/TRGIN: J2.1; also elsewhere on the board
GND: J1.3, J2.3, J3.3, J4.3, J5.3, J6.3; also elsewhere on the board

Parts:
C27: .0022; C_0805_2012Metric
C28, C36: .001; C_0805_2012Metric
C35: .0068; C_0805_2012Metric
C37: .018; C_0805_2012Metric
C38: .047; C_0805_2012Metric
L1: 45mH; PinHeader_1x02_P2.54mm_Vertical
Q7, Q12: Q_NPN_BCE; SOT-89-3
R52, R54: 10k; R_0805_2012Metric
R53: 47k; R_0805_2012Metric
R55, R59: 1M; R_0805_2012Metric
R56: 2.2M; R_0805_2012Metric
R57: 82k; R_0805_2012Metric

Connections:
/Hi Hats/NOISEIN: C36.1; also elsewhere on the board
/Hi Hats/NOISYOUT: C28.2; also elsewhere on the board
/Hi Hats/TRGIN: C38.1; also elsewhere on the board
/OUTPUT/ACCENT-IN: C27.2; also elsewhere on the board
GND: C37.2, Q7.3 (E), R55.2, R59.2; also elsewhere on the board
unnamed: C27.1, R52.2
unnamed: C28.1, R53.2
unnamed: C35.2, L1.2, Q7.2 (C), R52.1, R53.1
unnamed: C36.2, R54.1
unnamed: C37.1, R56.1, R57.2
unnamed: C38.2, Q12.1 (B), R59.1
unnamed: Q7.1 (B), R54.2, R55.1, R56.2
unnamed: Q12.3 (E), R57.1

Parts:
C25, C29: .0022; C_0805_2012Metric
C30, C31: .0015; C_0805_2012Metric
C32: 47p; C_0805_2012Metric
C33: .0027; C_0805_2012Metric
D4: D; D_SOD-123F
Q6: Q_NPN_BCE; SOT-89-3
R40: 10k; R_0805_2012Metric
R41: 47k; R_0805_2012Metric
R42: 270; R_0805_2012Metric
R43: 2.2M; R_0805_2012Metric
R44, R45: 22k; R_0805_2012Metric
R46, R48: 33k; R_0805_2012Metric
R47: 100k; R_0805_2012Metric

Connections:
/OUTPUT/ACCENT-IN: C25.2; also elsewhere on the board
/Rim Shot/TRGIN: C33.1, R48.1; also elsewhere on the board
GND: C32.2, R42.2, R44.2, R45.2, R47.2, R48.2; also elsewhere on the board
unnamed: C25.1, R41.2
unnamed: C29.1, C30.1, D4.1 (K), R45.1
unnamed: C29.2, Q6.2 (C), R40.2, R41.1, R43.1
unnamed: C30.2, C31.1, R44.1
unnamed: C31.2, Q6.1 (B), R43.2
unnamed: C32.1, D4.2 (A), R46.2
unnamed: C33.2, R46.1, R47.1
unnamed: Q6.3 (E), R42.1

Parts:
C14: 22/10; CP_Radial_D5.0mm_P2.50mm
C34: .0022; C_0805_2012Metric
Q8, Q9: Q_NPN_BCE; SOT-89-3
R24: 1K; R_0805_2012Metric
R49: 10k; R_0805_2012Metric
R50, R51: 2.2M; R_0805_2012Metric
VR7: 10kB; Potentiometer_Bourns_3339P_Vertical_HandSoldering

Connections:
/Hi Hats/NOISEIN: VR7.2; also elsewhere on the board
GND: C14.2, Q8.3 (E), Q9.3 (E); also elsewhere on the board
unnamed: C14.1, R24.1, R49.2, VR7.1
unnamed: C34.1, Q8.2 (C), R49.1, R50.1
unnamed: C34.2, Q9.1 (B), R51.2
unnamed: Q8.1 (B), R50.2
unnamed: Q9.2 (C), R51.1, VR7.3

Parts:
C1: .047; C_0805_2012Metric
C2, C3, C4, C5: .068; C_0805_2012Metric
C?26: .027; C_0805_2012Metric
Q1, Q2: Q_NPN_BCE; SOT-89-3
R1: 1k; R_0805_2012Metric
R2: 220k; R_0805_2012Metric
R4: 10k; R_0805_2012Metric
R5: 2.2M; R_0805_2012Metric
R6, R7, R8, R9: 22k; R_0805_2012Metric
R10: 150k; R_0805_2012Metric
R11: 680k; R_0805_2012Metric
R12: 820; R_0805_2012Metric

Connections:
/Kick/TRGIN: R11.2; also elsewhere on the board
/OUTPUT/ACCENT-IN: C?26.2; also elsewhere on the board
GND: R1.1, R7.1, R8.1, R9.1, R12.1; also elsewhere on the board
unnamed: C1.1, C5.2, Q2.2 (C), R4.1, R5.2
unnamed: C1.2, Q1.1 (B), R2.1
unnamed: C2.1, C3.2, R7.2, R11.1
unnamed: C2.2, Q2.1 (B), R5.1
unnamed: C3.1, C4.2, R8.2
unnamed: C4.1, C5.1, R9.2
unnamed: C?26.1, R10.1
unnamed: Q1.2 (C), R2.2, R6.1, R10.2
unnamed: Q1.3 (E), R1.2
unnamed: Q2.3 (E), R12.2

Parts:
C15: .0068; C_0805_2012Metric
C19: .027; C_0805_2012Metric
C20: .0056; C_0805_2012Metric
C21: .0047; C_0805_2012Metric
C22: .001; C_0805_2012Metric
C23: .0022; C_0805_2012Metric
C?16, C?17: .0068; C_0805_2012Metric
C?18: .0047; C_0805_2012Metric
D3: D; D_SOD-123F
Q10, Q11: Q_NPN_BCE; SOT-89-3
R25, R35, R36, R37: 10k; R_0805_2012Metric
R26: 180k; R_0805_2012Metric
R27: 330; R_0805_2012Metric
R28, R33: 2.2M; R_0805_2012Metric
R29, R281: 22k; R_0805_2012Metric
R30: 470k; R_0805_2012Metric
R32: 120k; R_0805_2012Metric
R34: 1M; R_0805_2012Metric
R38: 47k; R_0805_2012Metric

Connections:
/Hi Hats/NOISEIN: C23.1; also elsewhere on the board
/Hi Hats/NOISYOUT: C22.2; also elsewhere on the board
/OUTPUT/ACCENT-IN: C21.2, C?18.2; also elsewhere on the board
/Snare/TRGIN: D3.2 (A), R30.2; also elsewhere on the board
GND: C19.2, Q11.3 (E), R27.2, R29.2, R34.2, R281.2; also elsewhere on the board
unnamed: C15.1, C?16.2, R30.1, R281.1
unnamed: C15.2, Q10.1 (B), R28.2
unnamed: C19.1, R32.2, R33.1
unnamed: C20.2, Q11.2 (C), R36.2, R37.1, R38.1
unnamed: C21.1, R37.2
unnamed: C22.1, R38.2
unnamed: C23.2, R35.1
unnamed: C?16.1, C?17.1, R29.1
unnamed: C?17.2, Q10.2 (C), R25.2, R26.1, R28.1
unnamed: C?18.1, R26.2
unnamed: D3.1 (K), R32.1
unnamed: Q10.3 (E), R27.1
unnamed: Q11.1 (B), R33.2, R34.1, R35.2

Parts:
C6: .15/35; CP_Radial_D5.0mm_P2.50mm
C7, C12: 22/10; CP_Radial_D5.0mm_P2.50mm
C8, C9, C11, C24: 4.7/35; CP_Radial_D5.0mm_P2.50mm
C10: .0018; C_0805_2012Metric
D1, D2: D; D_SOD-123F
J7: Accent OUT; PinHeader_1x02_P2.54mm_Vertical
Q3: Q_NJFET_SGD; TO-92L_HandSolder
Q4: Q_NPN_BCE; SOT-89-3
R13, R18: 2.2M; R_0805_2012Metric
R14, R21: 100k; R_0805_2012Metric
R15, R102: 68k; R_0805_2012Metric
R16: 680k; R_0805_2012Metric
R17, R22, R60: 1k; R_0805_2012Metric
R19: 10k; R_0805_2012Metric
R20: 100; R_0805_2012Metric
R39: 47k; R_0805_2012Metric
R101: 22k; R_0805_2012Metric
VR1: 1MA; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical
VR2: 10kA; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical
VR4: 500kC; Potentiometer_Alpha_RD901F-40-00D_Single_Vertical

Connections:
/Hi Hats/NOISYOUT: C8.2, VR2.1; also elsewhere on the board
/OUTPUT/ACCENT-IN: C24.2, R39.1; also elsewhere on the board
/OUTPUT/OUT: C11.2, R21.1; also elsewhere on the board
/OUTPUT/TRGIN: D1.2 (A); also elsewhere on the board
GND: C6.2, C7.2, C12.2, R16.2, R20.2, R21.2, R39.2, R102.2, VR2.3; also elsewhere on the board
unnamed: C6.1, R60.2
unnamed: C7.1, R13.2, R15.2, R101.2, R102.1
unnamed: C8.1, Q3.1 (S), R14.2, R15.1
unnamed: C9.1, Q4.1 (B), R18.2, VR1.2
unnamed: C9.2, R17.2
unnamed: C10.1, VR1.1
unnamed: C10.2, C11.1, Q4.2 (C), R18.1, R19.2
unnamed: C12.1, R19.1, R22.2, R101.1
unnamed: C24.1, R14.1, VR4.1
unnamed: D1.1 (K), R60.1
unnamed: D2.1 (K), R16.1
unnamed: D2.2 (A), Q3.2 (G), R13.1
unnamed: Q3.3 (D), VR4.2
unnamed: Q4.3 (E), R20.1
unnamed: R17.1, VR2.2

Parts:
C101, C102: 100n; C_0805_2012Metric
D101, D102: D; D_SOD-123F
J100: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
R110, R120: 100k; R_0805_2012Metric

Connections:
GND: C101.1, C102.2, J100.3, J100.4, J100.5, J100.6, J100.7, J100.8, R110.2; also elsewhere on the board
unnamed: C101.2, D101.2 (A)
unnamed: C102.1, D102.1 (K), R120.1
unnamed: D101.1 (K), J100.9, J100.10
unnamed: D102.2 (A), J100.1, J100.2

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
Board: 2 copper layers, 40.0 x 105.0 mm, 129 parts (1 on the bottom side), 75 nets.

## Commit log

2022-05-05 License & Intro
    Adding License and a Project description
2022-05-05 Revert "License & Intro"
    This reverts commit 247f3665e0f948979af854c8499438abd3c0e66a.
2022-05-05 Let me finish it
2022-05-05 Now?
2022-05-05 Hihi
2022-05-05 Stop
2022-05-05 Lol read it
2022-05-05 All needed files were installed
    Installed .pro .sch .kicad_pcb files
2022-05-05 Kick & Snare added
    Added all files for Kick and Snare circuit
2022-05-05 Update Kick
    Full Kick Schematic
2022-05-05 Kick update
    Updated Kick schematic with two global flags
2022-05-05 Gitignore reload
2022-05-05 Kick & Snare
    Kick and Snare Schematics are now linked in the main Project
2022-05-07 Added drums
    Added all drum schematics.
2022-05-08 rearrange submodules
    rearrange hirachial schematics in the main view.
2022-05-08 Accent
    Added the accent section in the output submodule
2022-05-08 Output finished
    Finished the output schematic and routed alll the traces between the submodules
2022-05-08 small changes
    just some small overall changes (not relevant
    )
2022-05-09 Values
    Added Values to all components
2022-05-09 Resistor enumeration
    All resistors, diodes and transistors get numbers
2022-05-09 Footprints added
    Added most of the footprints for a 0805 SMD PCB. some placeholder footprints added and some missing
2022-05-22 SMD PCB
    added all all Pcb layouts without CP footprint
2022-09-07 changed some stuff
